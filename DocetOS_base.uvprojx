# Keil uVision project DocetOS_base.uvprojx, settings and files
target STM32F303 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DocetOS_base
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,STM32F4XX,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7, DEBUG
  c misc: --c99
  c include: .\OS;.\Demonstrations;.\Utils
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group System
    ./utils/: retarget.c config.c
  group Source Files
    ./: main.c
  group OS
    ./OS/: os_asm.s os.c os.h os_internal.h task.h task.c fixedPriorityScheduler.c fixedPriorityScheduler.h itc_queue.c itc_queue.h memory.c memory.h mutex.c mutex.h semaphore.c semaphore.h tcb_priority_queue.c tcb_priority_queue.h
  group Debug
    ./utils/: hardfault.c
  group Utils
    ./Utils/: debugTools.h
  group Demonstrations
    ./Demonstrations/: demonstration_tasks.h fps_demonstration.c itc_demonstration.c mp_demonstration.c mux_demonstration.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
